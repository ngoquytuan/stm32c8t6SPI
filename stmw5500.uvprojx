# Keil uVision project stmw5500.uvprojx, settings and files
target c8t6w5500 (6120000::V6.12::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stmw5500 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\source;.\source\util;.\source\PlatformHandler;.\source\ethernet;.\source\ethernet\W5500;.\source\FatFs;.\source\ethernet\SNMP;.\source\ethernet\httpServer;.\source\ethernet\SNTP;.\source\ethernet\DNS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./source/: main.c
  group handler
    ./source/PlatformHandler/: rccHandler.c stm32f10x_it.c uartHandler.c timerHandler.c delay.c spiconfig.c w5500init.c stm32f1fatfs.c
    ./source/ethernet/: wizchip_conf.c socket.c ntpserver.c
    ./source/ethernet/W5500/: w5500.c
    ./source/ethernet/SNMP/: snmp.c snmp_custom.c
    ./source/ethernet/SNTP/: sntp.c
    ../stmsdcard2Aug2019/stmsdcard/source/ethernet/DNS/: dns.c
  group fatfs
    ./source/FatFs/: mmcstm32.c ff.c ffsystem.c ffunicode.c
  group web
    ./source/ethernet/httpServer/: ConfigData.c httpParser.c httpServer.c httpUtil.c eeprom_stm.c
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
